require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1a11c4bb67503e2a5ef10b96bbe11b61"
SRC_URI[sha256sum] = "98e4d82a6e349fb6f4cba29a37d74b9955db340772c8d8810617a85fbb10eec4"
