require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "d9557391a3ab696089d657cb3a2b608e"
SRC_URI[sha256sum] = "83dc0b1152043d4e04e6135ea65accc749424b498ee018de9b390d712ccbc065"
