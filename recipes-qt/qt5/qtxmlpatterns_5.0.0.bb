require ${PN}.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "5a76672bc411bb9cd1e0158d86706062"
SRC_URI[sha256sum] = "689d7d89fe71b8fba53183825294bc769ffe1a60dae4ccf5fa3ee6fe704b5172"

