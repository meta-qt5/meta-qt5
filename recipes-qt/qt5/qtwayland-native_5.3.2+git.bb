require qt5-git.inc
require ${PN}.inc

SRCREV = "98dca3b54f52f08117c1e0d3a1b4826ed12ef23f"

# this wasn't released, the PV is set just to signify that this SRCREV was tested together
# with 5.3.2 version of other modules
PV = "5.3.2"
DEFAULT_PREFERENCE = "1"
