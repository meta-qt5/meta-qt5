require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "2333d25916a74260ce39b8a77c7c4288"
SRC_URI[sha256sum] = "79d99e826bf49e469a651cdc2d499d8b54e52bb8aaa279719a3afa03eba5d0ff"
