require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "959a9ebac4faa0464368a318fa677ab6"
SRC_URI[sha256sum] = "fa0954e5f100d38291fd3b3c8c92ade11710b25ae48018af7451c631982d924c"
