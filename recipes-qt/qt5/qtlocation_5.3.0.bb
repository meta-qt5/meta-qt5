require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "bfc7678bfe7d78f12fb20a54ac54e610"
SRC_URI[sha256sum] = "ca34224a8aa5e6f81c04cbeb05ecc440b82cf27ac24f7c2b1d297a3497110414"
