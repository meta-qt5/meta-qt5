require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a23fba03a4b48f36fe8b51d326d08acc"
SRC_URI[sha256sum] = "7e32b8d6e1d64ca4bdfa92d15f9b4217a1b24239ef40e8826eeccbe918866690"
