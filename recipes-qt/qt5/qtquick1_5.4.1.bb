require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "16d711d20238e3220fc4030dab608f0b"
SRC_URI[sha256sum] = "eb5324c784eef15b3d0f7e2fc2265b0f2e823a31330e88e09379972313ca432d"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"

