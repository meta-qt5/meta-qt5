require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "f56b2e6c537f6853d9bf10380c39418b"
SRC_URI[sha256sum] = "ff2f850f63798441aaaa0b18c741460acdd62c74d6a9e6a76521956e4bcb27d5"
