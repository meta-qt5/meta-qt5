require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "bcb4b546d1d39f2e27425b48bae90ac2"
SRC_URI[sha256sum] = "5cfd74323e8145a282fe840c47c639c064e832263744a24270f326a1464830ee"
