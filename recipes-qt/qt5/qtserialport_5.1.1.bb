require qt5-${PV}.inc
require ${PN}.inc

LIC_FILES_CHKSUM = "file://LICENSE.LGPL;md5=4fbd65380cdd255951079008b364516c \
                    file://LICENSE.FDL;md5=3801d7932fdc07fd9efe89f9854a6caa \
                    file://LGPL_EXCEPTION.txt;md5=eb6c371255e1262c55ae9b652a90b528\
"

SRC_URI[md5sum] = "83bba7e8f27d6d6d5a0d2fdcb5641d7f"
SRC_URI[sha256sum] = "aee1a277b64dc70be6d7d0504e35f2df52a83b41ab65c344119e76222ceb063b"
