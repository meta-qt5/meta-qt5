require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0497b5b46540848e0db6a9e219d756fb"
SRC_URI[sha256sum] = "e47122ed15e8e1cc32e11b3cd89bacc056437215134a204899f2fddb4fd92e5b"
