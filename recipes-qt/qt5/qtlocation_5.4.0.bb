require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "76cbd4d7acf5b319ed1d9454aac0477b"
SRC_URI[sha256sum] = "e8420c1b5fdddbc44faa7aa1c653da91dc101055a869dcb518326188be81d456"
