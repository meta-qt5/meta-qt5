require qt5-${PV}.inc
require ${PN}.inc

LIC_FILES_CHKSUM = "file://LICENSE.LGPL;md5=4fbd65380cdd255951079008b364516c \
                    file://LICENSE.FDL;md5=3801d7932fdc07fd9efe89f9854a6caa \
                    file://LGPL_EXCEPTION.txt;md5=eb6c371255e1262c55ae9b652a90b528\
"

SRC_URI[md5sum] = "1f70621ae40cbda948106b070c6c37d2"
SRC_URI[sha256sum] = "0f36803c480b2b7111b343e9dd871ffab1b4fd53147bd564125ef2994b09cfb9"
