require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a27360f16e4ca31e3d1098d1b2feba73"
SRC_URI[sha256sum] = "f8078a87df729103e6009432e5b784531842997197827f67db8a34f1715f8921"
