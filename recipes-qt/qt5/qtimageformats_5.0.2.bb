require qt5-${PV}.inc
require ${PN}.inc

PR = "r1"

SRC_URI[md5sum] = "e397a4237f51cfef7a3b38ad29b831d7"
SRC_URI[sha256sum] = "93bd13a47002f188a8a83a5c742d396a2008a545fc22d58df442c4c070a463b7"
