require qt5-${PV}.inc
require ${PN}.inc
