require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1d1ebc4d6efa4d05368c0c716858d314"
SRC_URI[sha256sum] = "9d06493a4387d19e561f79f79c0a9c4c333eb764d64af54dc05f13a978694537"
