require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a20d99a1c2afbd6a7c6f54e615f1bd63"
SRC_URI[sha256sum] = "ac089723489ee9146020bd8fc715358249d8cea7f2a2e92a692e2a5595a46b5c"
