require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "2d0f9403f607f617bcc13d4814f41365"
SRC_URI[sha256sum] = "dc37d21db1d4d8cdc2808ee24c7354643bc0b2ff71f9631bd8cfded388a4d9ac"
