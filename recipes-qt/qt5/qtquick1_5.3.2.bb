require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3a57c52d6d4d6632d67a4ebd35abe0c5"
SRC_URI[sha256sum] = "9b7b2e895180e4e3e1ed4e7b5ad049b7d021a05c96be6edc5fc433c6de6273fb"
