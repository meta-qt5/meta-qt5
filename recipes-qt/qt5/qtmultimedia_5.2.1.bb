require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "26dc22c59fbbad9fdf0699d5f887166a"
SRC_URI[sha256sum] = "62688cb7d8daa4d7050353fe39536c5edd97228a10185b9662a29b8c8cff1fa2"
