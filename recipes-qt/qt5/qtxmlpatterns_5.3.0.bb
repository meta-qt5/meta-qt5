require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "68c6e1311ecf8727368961739243d3b2"
SRC_URI[sha256sum] = "ac66c182f28a3909dc939a111d2bf701056f6c68cecde54074c9c34637cdc988"
