require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1378e18aecd8cc223deb729c8f0a735d"
SRC_URI[sha256sum] = "390e16e719e41bcc94fd79866a0909b70235513778063c5e47227b8b9876e0cf"
