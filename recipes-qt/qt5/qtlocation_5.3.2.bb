require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1ad3ee98f6f5d71df8dda14edc06346c"
SRC_URI[sha256sum] = "37b4072b531c35389b3acbbbd7259ab6ce4106177b96d67bfe5d3236139814d7"
