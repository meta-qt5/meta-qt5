require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4535ff78b5a9a18ffba702298a48e22e"
SRC_URI[sha256sum] = "ae868892a586cd0622a558fda6ebada8edadb575edf3b50e5569fd7115b6e805"
