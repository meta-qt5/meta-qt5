require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "691b0b71e4ad791a37e288b41979662c"
SRC_URI[sha256sum] = "0fc619ef714f5b920ff19ec811b6459c849fafcc697ef4091dbb74e45bd058c3"
