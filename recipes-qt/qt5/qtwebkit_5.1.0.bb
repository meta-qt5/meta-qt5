require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "fad7e7d6637719c2be101f9b3957d451"
SRC_URI[sha256sum] = "b49c4cfae697ea67142e7b35ecb0e3fec06814153e8226b8c6655c4dafc92ac3"
