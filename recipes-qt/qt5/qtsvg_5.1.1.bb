require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "9db8209602b0ea942273e01a874ea5b7"
SRC_URI[sha256sum] = "6bfe7705ff58391205ca797d84ca6dda57ebcce106fdff52d4908b0e443567bf"

