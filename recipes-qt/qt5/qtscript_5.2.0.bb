require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "37d32c983c3fdf5b29f932265046f2e3"
SRC_URI[sha256sum] = "ea717e633c9a586dc66b435aad50c9870d6f0c4d1bc185f91144b002bd060294"
