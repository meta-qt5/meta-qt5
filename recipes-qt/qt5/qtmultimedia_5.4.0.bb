require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3a6a415813b54a54cf283a5e2906e012"
SRC_URI[sha256sum] = "5ab9dba27ae64123f2d0124b6884da276d8982aa959d65aa44125f758ef9af51"
