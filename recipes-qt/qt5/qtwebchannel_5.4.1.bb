require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "bb914134c164c6758a0074748cc678ff"
SRC_URI[sha256sum] = "c4acb9ec9886fca6d0c2adc5b45970347ae1b3e4b5e0055ab370540faef7b251"
