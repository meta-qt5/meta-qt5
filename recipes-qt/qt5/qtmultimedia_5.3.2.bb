require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5ef68e85b9d32865a4bf7f491ff31f96"
SRC_URI[sha256sum] = "255fac66c93f33743c707da3d41d95c7c562924fe4eb829cbb7b21b2274a0e0b"
