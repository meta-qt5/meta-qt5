require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "d01c6b837db4a6dee69a3f0352b37e18"
SRC_URI[sha256sum] = "bed7b5edd8efc3d5b45c60b5ed949aec6a4daadb5f3bd9029467e90c4ef566d2"
