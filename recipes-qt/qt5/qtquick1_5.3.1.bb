require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "401ebe552dc76041e2485507ecbdfc80"
SRC_URI[sha256sum] = "44902d12a0a711e39f611db1cedff4e4144c21d9f0d6527181a132224381191f"
