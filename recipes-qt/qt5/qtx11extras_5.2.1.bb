require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "ad94a2f14afc3f2dfe9743027860c28a"
SRC_URI[sha256sum] = "4f62647772d37d27921a77caf6e02c51fb207c5a1d604b0b3047a92d0163d4b9"
