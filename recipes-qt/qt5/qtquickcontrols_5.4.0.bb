require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "6d2b408526b6197ff2edc32ac3238252"
SRC_URI[sha256sum] = "b59f43333291c3e73f9a9f92706a4c98d4d810b4efd6803a4edd3f1658fae61e"
