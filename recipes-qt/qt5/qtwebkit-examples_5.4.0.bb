require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "369617a40e64b93686cebd12a99916c0"
SRC_URI[sha256sum] = "b02a2f3d381e66e83fbf972416ad376e2a03ccfa8b4371867c83970bf0f0e9f6"
