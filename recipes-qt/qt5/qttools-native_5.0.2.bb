require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "93ddcfdb87c6a784b0a921d09eafbdad"
SRC_URI[sha256sum] = "bb9bcf38dbb429cf884d688793681257876f97a2c0fba08528393a39eec7755b"
