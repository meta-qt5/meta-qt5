require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "b373739f085207dda92b3399d477faf8"
SRC_URI[sha256sum] = "c4108979f869645d91d7bcc2004b4bcfbae7332c1281ed5697a551a0d046e98c"
