require ${PN}.inc
require qt5-5.0.0+git.inc

PR = "${INC_PR}.0"

SRCREV = "b41c2151fdfca3f63a6cd45f6c69ae678694b63e"
