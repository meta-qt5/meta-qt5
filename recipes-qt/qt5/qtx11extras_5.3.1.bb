require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "184cdea8945a6d62131fae75c673225d"
SRC_URI[sha256sum] = "25fa2801367c050ac19ad3b6f92d38890314c9cbf2d833b1571e1a7ea22b4f71"
