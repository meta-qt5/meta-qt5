require qtbase.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "589addbcc525a43c0ace55652f755dce"
SRC_URI[sha256sum] = "ad07d4d46e810f1371f4aafd66d97d48e8a1c1165d633bc9266ca9aea6087805"
