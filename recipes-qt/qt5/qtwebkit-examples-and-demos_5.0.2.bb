require qt5-${PV}.inc
require ${PN}.inc


SRC_URI[md5sum] = "9c48df80ba9bb3587b4d6ec35daf840a"
SRC_URI[sha256sum] = "10981ae3a6775387badce33542733d63895c5a62b3b33e0973d782ec1b9174e6"
