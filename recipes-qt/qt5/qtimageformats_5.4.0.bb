require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "608dbe53d5d3a0872eb20025b681d1dc"
SRC_URI[sha256sum] = "c89b678df71e44f8cff7b5f8362b7d61430a7aa7cd70147be1267d87ac8fe046"
