require qt5-${PV}.inc
require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "85aad9f287910c21c8464d7d1ea010a9"
SRC_URI[sha256sum] = "6ff4038f8db68be51661d1a6646f510b26f6ebbecbdeefb76cd8361f808768f6"
