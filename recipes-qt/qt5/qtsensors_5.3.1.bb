require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "ce3868ac3be057ba112f4c8f6da67e94"
SRC_URI[sha256sum] = "8f41113571ace59f88e91d74e113e24f8f934f6b571da3c976b53bd42e86c238"
