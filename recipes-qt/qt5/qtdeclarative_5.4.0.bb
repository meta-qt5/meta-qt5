require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4f928e52e72b5e867b50b4d409d5e99b"
SRC_URI[sha256sum] = "e67c9275b0f6869a7c1e8023ad7c0a23fb19f8a8d2f350371e954ead0cfad7b6"
