require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a4170d057978794c2c3c477e841a0e08"
SRC_URI[sha256sum] = "3f95fb603fb3c7fbb54587b3dfe423491e058fd61af2d7371b1f12881cff20c1"
