require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1436680e00ea3e211fd0abdb7c18014a"
SRC_URI[sha256sum] = "3f6c5bb568ebbee24700c439a60b2e512026dfee5be896c846e4f289cc5b846f"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"

