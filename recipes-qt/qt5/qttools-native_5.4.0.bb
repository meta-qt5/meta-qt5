require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "9074cc89bc52aea7f76a4d231d2f0ef6"
SRC_URI[sha256sum] = "5d39cdc63d43ae1f954517e517d9a5c24f2b2c91e22dab3ae6b5b81deb49983e"
