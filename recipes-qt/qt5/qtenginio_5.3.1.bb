require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "89bffcd329886fd1fe4e504c666987cd"
SRC_URI[sha256sum] = "6e1ba11fb84f9778497baff1ae06364d8ff13cd79a66d671a35832e7e856702d"
