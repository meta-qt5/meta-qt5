require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "255bb7f28c667ab91303e6af271753b5"
SRC_URI[sha256sum] = "d303cbceb73774edc0cfdbde6b97b0e41077e242ff6520710890f81bea40e2d4"
