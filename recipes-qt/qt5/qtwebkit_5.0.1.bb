require qt5-${PV}.inc
require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8210ea90902c4ec526e1e5f7e719ad57"
SRC_URI[sha256sum] = "e1f3a5ff14277a57fa4235d1e3d2ec0029fc888e6e4855b7f7874028ad827cfa"
