require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "044f7d3f92c45dd76072077826ca4a07"
SRC_URI[sha256sum] = "8a0f33ccf572b9fbcdc46fca602d75270979a2f851b6a1f399d039b1f7aae159"
