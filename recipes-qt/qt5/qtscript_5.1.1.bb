require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5c0e8633fbf560f711b7af689f8bcb99"
SRC_URI[sha256sum] = "d80061f7652ae3992e2b9ffbc7052d54872f6042a7a258b50d22eadf0175f364"
