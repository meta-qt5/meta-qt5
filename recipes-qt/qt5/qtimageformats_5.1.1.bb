require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "209edddd5899b36ea7ea7ad52204a593"
SRC_URI[sha256sum] = "3bbb7825c0298c7d95d26b205e48da02c5bac3b35d66a601f939f8ee8b3463a4"
