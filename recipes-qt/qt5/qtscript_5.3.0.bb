require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4f755c8810946246adcfbaa74fafae62"
SRC_URI[sha256sum] = "a86067103ffb4c307619aeaef68fbe25e7219ffd34b369e445cdd4deb4108390"
