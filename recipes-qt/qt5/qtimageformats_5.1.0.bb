require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "6dfab2e481e90ce74e89c646b91a11ca"
SRC_URI[sha256sum] = "c740442a46715e32a45f60e42fda76afd8430bf0004ee1f7147aa77cf92ed846"
