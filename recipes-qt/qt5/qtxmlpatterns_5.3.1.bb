require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "d263163cc6e9ba7a4e8bd6c558f3ae42"
SRC_URI[sha256sum] = "c597ed383d1d433960ffeb4a3784979235a399e62b27b60b5d67aa2c9aa8653f"
