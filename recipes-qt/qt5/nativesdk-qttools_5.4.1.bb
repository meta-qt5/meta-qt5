require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5b2fd42304e9294bc0f77095fdb35ad6"
SRC_URI[sha256sum] = "11de0f8573843194b134e32af49594514498fadc4fc0b3b0333540fe1f671f72"
