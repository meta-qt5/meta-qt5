require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0787b72a67d1e38a3a47b54b84a6dc42"
SRC_URI[sha256sum] = "ac4b8e2ef7520e674eb53848ec3d459d8ae92735093106b93104dec7f65edbf8"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"

