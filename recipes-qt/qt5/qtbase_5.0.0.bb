require ${PN}.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c29073bfc3cf6b39492a2481d982386e"
SRC_URI[sha256sum] = "89bcde09b24e8139f9d1d957dcb07c5aada83d578c84279f66813f348243d500"
