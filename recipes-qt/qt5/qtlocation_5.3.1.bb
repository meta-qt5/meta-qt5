require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "697731ec5aaf482826495cd419cab4f0"
SRC_URI[sha256sum] = "1b3f262569c329cddfd9355994a47b7f62b70f15343e1d818c706bf4473dbbf5"
