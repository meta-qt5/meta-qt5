require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "7225169d7d166cc5660384a85e4d4a2f"
SRC_URI[sha256sum] = "42628eac133738df30e9104c2014eb70478e8fcf2cc86c1f500359c12216b192"
