require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0ced83d5555e969f05e1ea89607ad584"
SRC_URI[sha256sum] = "715f2e5196a29176bdb9980bf99334e5c8aefe5f4aac961d7de3c53b0a432ce6"
