require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "045f98acba9fba0358a6a50356be0841"
SRC_URI[sha256sum] = "09403e7e088f30da828e452559a6904d7c43420d423a429d6529285f99b1e407"
