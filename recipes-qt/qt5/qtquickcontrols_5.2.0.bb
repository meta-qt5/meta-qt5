require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "748ab947f59fb104db2ac1fefa073d81"
SRC_URI[sha256sum] = "c778c364d8d438ff7939c540f56ea741e4b5b957b620b194c2e881c775ab582c"

