require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "628a91ddfe34efc6622fdba8c6348855"
SRC_URI[sha256sum] = "f64d2ca5dc59ab8980987649bcef4597a7c0194e802e64d93448cac892fd8250"
