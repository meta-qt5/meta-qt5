require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "955d1e4da875f3872ef3208f21a757dd"
SRC_URI[sha256sum] = "d4620e0b1aff6d2b6f4d8066e6f8258e012a8b5507af7c03b661029a1ffa75c9"
