require ${PN}.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "720e5061d75913dfa97bf8bef4a443df"
SRC_URI[sha256sum] = "6f8a0489eb057f6cba5e77cabaec13dcd010da562b3b88f91fe960022d7c37c8"
