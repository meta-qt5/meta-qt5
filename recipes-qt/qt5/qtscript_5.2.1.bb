require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "b8af09bb297d4c62e64df5418fe99dc9"
SRC_URI[sha256sum] = "6621350d5eff65cb6f9853247246f30a2d4cdb465c14923ff7ccbd8c3a9cdefa"
