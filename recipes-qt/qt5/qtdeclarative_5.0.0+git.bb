require ${PN}.inc
require qt5-5.0.0+git.inc

PR = "${INC_PR}.0"

SRCREV = "c8ef32e2b6cded37a6854b94a281464c1b7a298b"
