require qtbase.inc
require qt5-${PV}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "735b6d6c3711f59ee7d5454dc6b8a2f2"
SRC_URI[sha256sum] = "f62b238220f384d84587d0519fb7fa8961a4d70871d38d6a4bc4e4f013b8606f"
