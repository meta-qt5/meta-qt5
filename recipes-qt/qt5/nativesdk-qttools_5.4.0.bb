require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3de5923257b365526856094d7da0ad85"
SRC_URI[sha256sum] = "5a85a096ffd30463781dc3871ad9640a510eba0086188c7943d23adc3660741a"
