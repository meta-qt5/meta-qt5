require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "765579f4f64cb64a812c8a80104eb8ec"
SRC_URI[sha256sum] = "9a80d401dfbb64f109abf210cb32775a102f7b2420b3a3175b8dab0792220380"
