require qt5-${PV}.inc
require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "929db18c2f4f66cb2ba204076f9f0c22"
SRC_URI[sha256sum] = "def1b60e5ff5513cbda27200554fb568ef822e0ee790476facfe3bcf3438598f"
