require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4ab24c0bf04f21207a48f261ce0d7943"
SRC_URI[sha256sum] = "7e491050000c9608bf36f78bb3db5938b92e0dce89d686d903c85dc8fdadef38"
