require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "6f88c2a99002801a1943483331f8b4f0"
SRC_URI[sha256sum] = "c8081a0863b7d8e2e39ec0e2fe288331ddab093a682959ba7378392512296482"
