require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "cb2ef624b28b6ba61d6a467b8b3c314a"
SRC_URI[sha256sum] = "ec31e1c3cd5aea4d7dff946802a7fde2599bb8a1931d4bb49cb0854371cf1223"
