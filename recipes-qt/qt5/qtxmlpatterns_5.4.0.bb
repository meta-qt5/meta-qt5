require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5ad30d6b478d4e5d71e9c5bef3f3fbf7"
SRC_URI[sha256sum] = "791c697b9bc7a5384e3d0dbec56af7f2194fe7dc91f8b1e0fd502089135e5425"
