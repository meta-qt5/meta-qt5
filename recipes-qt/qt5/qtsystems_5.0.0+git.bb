require ${PN}.inc
require qt5-5.0.0+git.inc

PR = "${INC_PR}.0"

SRCREV = "2dbaae64ccd0fa3646d68d77cbc9baac7d3bde2e"
