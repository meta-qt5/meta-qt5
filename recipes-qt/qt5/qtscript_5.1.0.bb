require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "c9348cdc39826c717c75b930a7b5a3bf"
SRC_URI[sha256sum] = "0cbe2e472657673ec8bd2f1ad133140b498292065159e67355f427e903c46d9b"
