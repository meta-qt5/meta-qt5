require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "05956168e0a4bba44c31b61dd4fc5e6e"
SRC_URI[sha256sum] = "f5dc431fb33a195414d2d75d7dff1c101f4101489f38b4ea9c5e8782b1807a64"
