require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "c1fc247771a2fd1d238db8ffc4e65bbf"
SRC_URI[sha256sum] = "636685bbcccac28f6c8c2d1bee7c9b06a74bc5c11d9c87a424d80093f19b1038"
