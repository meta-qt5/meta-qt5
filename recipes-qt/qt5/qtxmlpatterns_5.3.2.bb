require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "857e8040b2bf45c114a7d75ec6ef94ee"
SRC_URI[sha256sum] = "acab0307039e117475caf2c95e425ead09ab5ee08ce15205fb3c0af7d7ec1abb"
