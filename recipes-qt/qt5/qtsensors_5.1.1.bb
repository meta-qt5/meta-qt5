require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "219607895e15348d723fa67324d7061a"
SRC_URI[sha256sum] = "07f2d94964b47786a33ba1e24049c81b29e95b791647f9116ea350dc4cbc814f"
