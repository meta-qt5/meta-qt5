require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "40d0989d68fb08c1184b7d5088da9c48"
SRC_URI[sha256sum] = "347c33ee496d67d98d64b6fa43797c45eae85752bb0026eb234bfb420f77febf"
