require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1a54f0495ad7239038f57d8a2715203c"
SRC_URI[sha256sum] = "c2daa131cd41f230d5903e1b754249ed16609df98a08e70b62b5610c4a3a1774"
