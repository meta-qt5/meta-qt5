require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4b6e74bd7752bc241617f41539632bba"
SRC_URI[sha256sum] = "df907a81c4ef15c9aec216c1f57aa72a7a7b274ea3cb3950f87fa1b04e369ebe"
