require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "46e4e8df94b4da4415aa5f5076b8bc45"
SRC_URI[sha256sum] = "d83555be4fc805afe9ef307cf8633d9c0cebc678042e384b24e0aa61d7bc1d02"
