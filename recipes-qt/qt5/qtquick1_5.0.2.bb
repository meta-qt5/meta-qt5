require qt5-${PV}.inc
require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "22cd03e2e2aadbc5e2ce324a3526fa8b"
SRC_URI[sha256sum] = "2a2235f4f4afd5bf8c6960efafbe89f8c443f174fb22931d48f566660cfcea9a"
