require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "e62d72c410dffe5129043f80f624c896"
SRC_URI[sha256sum] = "6c672207765d5d2e88aa14b72b3876ad7bce453397a02e1a3d6e4670a8d188c1"
