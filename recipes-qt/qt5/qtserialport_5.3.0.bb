require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "393a352f82f1f0000157834751a29578"
SRC_URI[sha256sum] = "772d230019c52452dc661e864debf1fd520460bddce8d8abda70a4dcc00e8d5f"
