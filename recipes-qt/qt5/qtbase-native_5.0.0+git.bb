require ${PN}.inc
require qt5-5.0.0+git.inc

PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"

SRCREV = "234163adb3ceb9a6f2fac04a276724bf8495ca8e"
