require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "7c3e94cd04603c3f81e50d47daf5bbc7"
SRC_URI[sha256sum] = "a8192ee70d8d3e9944a8d8f03521e3abf6beb7f6de1bf2d80871dfc4d9bd2a2a"
