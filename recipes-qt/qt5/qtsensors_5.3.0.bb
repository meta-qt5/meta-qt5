require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3f8c7e7ed87785d8c1fbab4fec6f458d"
SRC_URI[sha256sum] = "dde4d55635e616406adaf8e100dc468ccdd296c6589eff1208f0dce0ffc597c1"
