require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "8bf9b65e5a586091d0ce9f9107367f4a"
SRC_URI[sha256sum] = "62e790029ddf0c5eea7623958ef97144b3c94113cab1e9fa5fbf326625dba3bf"
