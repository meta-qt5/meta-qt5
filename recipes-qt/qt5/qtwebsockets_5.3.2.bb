require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "093ddc113952e47bd0e251986e03f1e4"
SRC_URI[sha256sum] = "60533d413b0fa27b1e08642ae77bcaa76a845fa39ddc3d49af573a77e73a38c2"
