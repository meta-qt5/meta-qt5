require qt5-native.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "2e1e5198a3a139099bfefe75ed29e043"
SRC_URI[sha256sum] = "d1a6b06fb3d44e83bbd5b7fe5bc1177ff437f992efafe0154cf37b18cfa87109"
