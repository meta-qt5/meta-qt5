require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0e38ef686197fbf1207a9510f07d0656"
SRC_URI[sha256sum] = "ea30ed7c3523d1a800a63cb888096cef89c61b590bfc81ba815ab9b12e283a89"
