require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3f6132475f6edcd7b6cfb57650846185"
SRC_URI[sha256sum] = "bad23ebcebf8e91cc727b229a3f87f95829edfd2a7653d47e97b154aac687c59"

