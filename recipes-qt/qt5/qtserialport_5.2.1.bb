require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "2993ad7e92a0b6b41e3cb0e0e345d251"
SRC_URI[sha256sum] = "f5754e4ba61843b7dfdf946a91b7d857a5cb470608b840f92452e72f24c67347"
