require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "90bffd1ea73d2f13322b25aa1b2d5e25"
SRC_URI[sha256sum] = "f6936130d7d2f08062dd9b9b19dcde56511ff038e57ae813fbb0943477871c1d"
