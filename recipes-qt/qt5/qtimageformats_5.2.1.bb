require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "9b88aa6f3888c7c7f5253c147ae4bf8f"
SRC_URI[sha256sum] = "a6a0454769566fec1757fb09b1f33c9fc70d4016acbb04ebc6e493ddedfef124"
