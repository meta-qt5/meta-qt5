require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "ae0301809ca504b4b67d817fd46f9a2e"
SRC_URI[sha256sum] = "1df262e4d8d16f83511a096974a5a14af21d366493c5302d549e3dc52fa0b00f"
