require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0db5f74de2a2e93bc2747a609ff81d5f"
SRC_URI[sha256sum] = "bc7b48347ce3ab5d6a22223c001659f3d898cbd3ef9e35688d7ad1bf8e7510b5"
