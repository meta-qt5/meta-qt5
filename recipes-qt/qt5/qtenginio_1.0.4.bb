QT_VERSION = "5.3.0"

require qt5-${QT_VERSION}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5870a3c01bbe175ed577f0c3f51f3f33"
SRC_URI[sha256sum] = "090f6f7a22a197fd5cd9acdb3f79fa0361d1662abed1c450fc9db67c089745d4"
