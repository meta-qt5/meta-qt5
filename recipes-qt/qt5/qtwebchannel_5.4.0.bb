require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "d11e86da2f585ea48f38d4107356edd7"
SRC_URI[sha256sum] = "24eb0125198270f8595babb6c0df74dd13e0ccc8c8a5e665151cf68c3306594c"
