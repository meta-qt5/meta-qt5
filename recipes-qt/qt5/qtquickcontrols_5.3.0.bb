require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "808b5a28f152f1af19dad30a10e5dbf1"
SRC_URI[sha256sum] = "b8df0d64b69e765971fd6c71d8f0c4f7aabec73343a98225a4655a0b8b82df1c"
