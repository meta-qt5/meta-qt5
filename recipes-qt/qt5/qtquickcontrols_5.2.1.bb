require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "027bc7d05fe740b21284dc909c9f11ac"
SRC_URI[sha256sum] = "eb03a69402576984d588923e994c3cb672d8479ac9b68ed90da15d0c2fd82aac"

