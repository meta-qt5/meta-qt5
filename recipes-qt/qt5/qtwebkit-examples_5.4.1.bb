require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "783bfd27e79769f3ceeb206a4921400b"
SRC_URI[sha256sum] = "19187bb31c349c67f90c92df896f14f9167b982bdef5187e83fd68407826720a"
