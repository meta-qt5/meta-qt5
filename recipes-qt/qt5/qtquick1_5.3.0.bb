require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "cd6ffd4a29f7050f71670e7afec09e5d"
SRC_URI[sha256sum] = "74b03938df58e7825b0e46efb8266ac8d53741fff1c467b5b1fbfe2f3b840b68"
