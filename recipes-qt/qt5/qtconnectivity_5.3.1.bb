require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "2693394de6dd97d3a054791cef77b928"
SRC_URI[sha256sum] = "dc5253a62e178a0882a74dc48114c7fd2a3e8feea91df0d9670f11d16361ee67"
