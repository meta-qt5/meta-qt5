require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "262c142aac926b492a1bf7fa3f9a96c2"
SRC_URI[sha256sum] = "5bbfa86bf646fbc863f2a674c83b366b65301d3e1529ffe86860eb90fca13a85"
