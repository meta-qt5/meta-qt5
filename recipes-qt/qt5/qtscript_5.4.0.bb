require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "b38b35643d85aea25ff1cbea84f76a82"
SRC_URI[sha256sum] = "f5f35702ec36f24b17878348af1aa1ecf93056a9ddf475097b3fdd52c3330ed0"
