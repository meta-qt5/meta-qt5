require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "ddad7d00ebd201a750242bd67b20ecf3"
SRC_URI[sha256sum] = "d5ecff99b4d35bc5f184503cabc394a554be48c368aba140f95019501645a7f5"
