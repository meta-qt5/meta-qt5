require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "275078e21f8d84c29e0cce6fd58ae28c"
SRC_URI[sha256sum] = "5b68ce55bab94d0d9dfa86ef7a2c3f402e931cc12fd028766f531148b9e31ddc"
