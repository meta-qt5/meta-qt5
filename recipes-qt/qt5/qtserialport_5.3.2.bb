require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0a38cfe5c81364f2b93d0d38b94d375f"
SRC_URI[sha256sum] = "a886e0cb08be60e57958676dc91c6f649468184a03c89c2aeabc904d36fd5a4b"
