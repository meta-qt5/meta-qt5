require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0f2bb8af6be2306b2b4d194a7ebf6fcc"
SRC_URI[sha256sum] = "69a47c5645918fc27bff630275685f300e42b4dfd99ccd3e5aa1c8a6d0725156"
