require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "c1c5b1072137773d308c8b498cf35d05"
SRC_URI[sha256sum] = "d5a8b77c1c4832383f3c5a39c6dc60e992e61e684e7fbbdf9a208c31d9d032dc"
