require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "59f6cbbdf2ad48c6b95b65f8b333df2d"
SRC_URI[sha256sum] = "ca6a28c95be0bf18080b4a20ae9e2c24a77a45aaf557f06047e65b1280c17251"
