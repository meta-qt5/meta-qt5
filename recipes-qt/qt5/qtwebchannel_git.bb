require qt5-git.inc
require ${PN}.inc

SRCREV = "86d77a900852691267f556fbde98406a12ee4310"
