require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a35e2df8ff2d6b99e4b33443165359f4"
SRC_URI[sha256sum] = "8006ca1cb13844772ac2926e662ab7a0eb16cb26157954cd415e0f6d641b4ed0"
