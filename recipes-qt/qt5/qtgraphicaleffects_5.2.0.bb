require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "85e94989bbc624f676102f0ea343b6dd"
SRC_URI[sha256sum] = "b28cefa95578cf5ed1dfcbc81da1cbec427400e56edf0ce81323b3f25e2a558d"
