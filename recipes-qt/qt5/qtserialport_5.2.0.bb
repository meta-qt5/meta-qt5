require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "7b90e0707b698331226e662bd39945e9"
SRC_URI[sha256sum] = "c7d5bb58d6c574275102d088159d0323aac40a639ceb4224aa06c34d2fe8d292"
