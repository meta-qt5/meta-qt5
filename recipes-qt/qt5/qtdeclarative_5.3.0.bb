require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "9e29d2b481c771ce5c798a3319835673"
SRC_URI[sha256sum] = "fab07eb4f4b2091e1d88b27b84ac49d7e8daaa1eb72fd62e602ee9ac3ed7f42f"
