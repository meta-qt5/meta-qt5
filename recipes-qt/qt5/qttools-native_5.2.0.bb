require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "76a0992967b6d02220ecb69a5ba04ef1"
SRC_URI[sha256sum] = "ff331510ecb776b3059953e216e9fa7a4c0736eeb148c4cf11acc8150811b7f0"
