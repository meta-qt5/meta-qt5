require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "6abbf131adffdf3cba63704d5d35f921"
SRC_URI[sha256sum] = "8b2bb3250b9e09a4c568069bc4c7cfeddbdcda50b24f0bfecc7f85df3120ff65"
