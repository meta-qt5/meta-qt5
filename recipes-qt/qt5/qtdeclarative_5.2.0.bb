require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0f7714c5c91b8eb7cdc1071f0a51c202"
SRC_URI[sha256sum] = "b81bd480216fda8ff1d96610e710ff5ca17e0d711c8e40753264f91a4e8f6d19"
