require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "bb4a74f3cd1db59274c9f4aaca0912af"
SRC_URI[sha256sum] = "8df057d527f98b1c2aa2941ff22adaf9b9c6441ea0e6c44f91f49bbcdbab57ce"
