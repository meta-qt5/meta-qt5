require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "a132295b896062d21ded0937a56d22a3"
SRC_URI[sha256sum] = "653b5e600b1cbf3275d0858415570d2a2611823a4651ee911e684dcae870d792"
