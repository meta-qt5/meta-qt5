require qt5-native.inc
require qt5-4.999+git.inc

PR = "${INC_PR}.0"

SRCREV = "22c234a34e8af6a26b374ef810630ba9e82c696a"
