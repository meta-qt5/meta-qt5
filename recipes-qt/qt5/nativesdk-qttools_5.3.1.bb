require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "7264920fc489ac878d40218263df8c4e"
SRC_URI[sha256sum] = "edf59eeead3c1d202883c2e6091abd1d40ac37b6e6b0e240b29ab75f86c515a7"
