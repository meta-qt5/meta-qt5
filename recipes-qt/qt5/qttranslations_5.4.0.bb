require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "6462eeefae00f048418ed6e4571c4cc9"
SRC_URI[sha256sum] = "aca78d9178481a21a7af8571beb9109b38f0f71ba75cf3b89ddf705962a3f98b"
