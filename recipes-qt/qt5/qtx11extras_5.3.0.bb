require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "83fc516c7f6ab82599b3f6e46744cb85"
SRC_URI[sha256sum] = "92d1c051294d92a250a405c120673721865b37d8f5db4eaac4b3f7fe46707719"
