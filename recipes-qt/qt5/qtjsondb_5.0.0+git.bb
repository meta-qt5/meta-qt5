require ${PN}.inc
require qt5-5.0.0+git.inc

PR = "${INC_PR}.0"

SRCREV = "c7c1e61bb5beddc3f4502548fd9ee498f1534e67"
