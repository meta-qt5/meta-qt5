require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "718606a6f76afa20c6cd2e0433356ac2"
SRC_URI[sha256sum] = "5934651affead2b7e70fd7a3dedcbfbf7ef3d7b64a9ac4142622f7afff578446"
