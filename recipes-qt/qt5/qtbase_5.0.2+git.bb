require ${PN}.inc
require qt5-5.0.2+git.inc

PR = "${INC_PR}.0"

SRCREV = "8e127d9df868952d41c8aa622b6d4ead8139a835"
