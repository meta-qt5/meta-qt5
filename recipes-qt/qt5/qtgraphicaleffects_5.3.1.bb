require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "bed5b36e721de1e356b879e5c811d799"
SRC_URI[sha256sum] = "53d8a4846f1fefb13aba4cebf3d3f808df69ec187cc435e895eb34152c4e860f"
