require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4d26d56c55b0117c37d96e85755da6a4"
SRC_URI[sha256sum] = "a43f10e532180eb8400fec65752b36c1adaa9aaf672146035ef630d324a38b19"
