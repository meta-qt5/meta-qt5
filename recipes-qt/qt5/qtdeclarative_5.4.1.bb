require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "86dfe5c41e14a142c72fdaa6a64f933c"
SRC_URI[sha256sum] = "15124e242a8a4a8fc5bedd32910b3b0b372b6c2b63f99572c4a2427e668d4417"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"
