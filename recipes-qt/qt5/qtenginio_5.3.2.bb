require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "53b67cf5470dfa9bcfc59aa5b8bfd66d"
SRC_URI[sha256sum] = "d5b84656dc6a349db380e42690a18137e562dbaba1930216bb3e3815df6af708"
