require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "2950c8df9da1e3d418a1e209d24f503a"
SRC_URI[sha256sum] = "fe0852c510b7ab9111310d6880d1b1f34908274099aefa5a14316173b25cfbc2"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"

