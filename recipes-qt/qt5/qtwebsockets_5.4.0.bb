require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0c406bca48296d0d99cc93b00f40aca7"
SRC_URI[sha256sum] = "2acd274a4a983cdd2288678d9005429fded51b5277d0621c4a953fa4f4f4cbdf"
