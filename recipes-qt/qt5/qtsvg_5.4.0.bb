require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "1c9921a44060bd98096b105c97556e68"
SRC_URI[sha256sum] = "68ee762bacc7b63aea29f446549ee6daae46e6fe2120e2460f30d47accc2b789"
