require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "660b4e169a13074d2edcc3110a7b5ba8"
SRC_URI[sha256sum] = "1297212198790f186cb647dcfa929fd2de0824bd04578cf041355e4eabb33ff2"
