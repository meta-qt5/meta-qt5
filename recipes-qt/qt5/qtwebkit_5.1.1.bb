require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "70e956dafcee1969de53d4de7b4691ad"
SRC_URI[sha256sum] = "d6ee1e9111b0996277a512ae71736a05faa7c0de6d69ac2978adce79c3116a24"
