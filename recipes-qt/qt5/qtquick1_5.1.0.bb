require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0c4c7b81258dd889e020b6025f542387"
SRC_URI[sha256sum] = "51d83033c2012de9806be13434b48430401c395c0d0a58390ada290581b3fc5f"
