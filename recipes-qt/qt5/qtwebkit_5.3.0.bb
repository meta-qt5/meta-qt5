require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "cc9197eaef9e7950e907635f9bde1e98"
SRC_URI[sha256sum] = "ceb1aeeede1febddbc10c5c23e6bcb18a90a5eb4d162d6f0b5075ff4ff3ba335"
