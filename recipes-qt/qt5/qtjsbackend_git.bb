require qt5-git.inc
require ${PN}.inc

SRCREV = "904d8b8825aa82dbc6b888968f983ba6aa339832"
