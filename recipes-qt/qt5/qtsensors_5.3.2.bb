require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "d0a8dc3173bfc9dc9f2632d509a76e6f"
SRC_URI[sha256sum] = "f9359dc42fbd7105eec7a1fb866e90aa772fd694075e5a5691d1a31d08953ae4"
