require ${PN}.inc
require qt5-git.inc

PR = "${INC_PR}.0"

SRCREV = "c97afb08eb28ce36f726fe427556622790a287c1"
