require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "394d33cc5d6b7aafbaae5a4f1d9e6652"
SRC_URI[sha256sum] = "50fc66ada43472e42245c18095e9eac84b496a634736cf55aac81326e4aad54a"
