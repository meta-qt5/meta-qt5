require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "8431a8476213b3a3587e04b023a2435f"
SRC_URI[sha256sum] = "80e7eb55ea6c4a4e92f44eb1d3cd7c9ecd85f9d5e48e682a31473633fa46a64e"
