require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "921f4596ca39b78851663369db0bbcee"
SRC_URI[sha256sum] = "9f30b9f0f758c44db4743d2de409cfa0aef297bc6b81c929b1875dfb638d517b"
