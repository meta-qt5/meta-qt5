require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "5827c61adba1d6921c51ef7ba1adce68"
SRC_URI[sha256sum] = "8d4b5845b0fd99511ea7e7901d46ba8d50dc1f19cbce4496f279677e7ac45aca"
