

require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "f2332bedc9c1ac8e762c62cfa71aa640"
SRC_URI[sha256sum] = "29b648f005e9e588714c8e3c2115db65c7a944a6ba84baafb84091d73213c5cd"
