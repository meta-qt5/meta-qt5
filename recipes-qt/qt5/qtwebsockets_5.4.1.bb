require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "308e1e9126e6fab8b06616db9810973e"
SRC_URI[sha256sum] = "daf56f98c5e267253bd2d2e421472fc02faa1703a9063cc14cf8afce6967ab44"
