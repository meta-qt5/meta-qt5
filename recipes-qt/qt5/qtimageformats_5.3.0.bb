require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "90c751ffe23c005eb411d1f081bf116d"
SRC_URI[sha256sum] = "f3b895847d27eaa98979ad146e6c0f46f38e23471a87ef496b8b777c578db2dc"
