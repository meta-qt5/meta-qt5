require ${PN}.inc
require qt5-5.0.2+git.inc

PR = "${INC_PR}.0"

SRCREV = "4c94a3ca55e82ade19ff5d4ab361d40e6252f2da"
