require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "f3a7b9b20dd5f19fc5ed12ef030c59b7"
SRC_URI[sha256sum] = "a3c66bc9e2b877109073f27bbc7865489fa1ed548584f5fc87c371380dc1474c"
