require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "4de8ca8ac1a3e5db20a903286fb78840"
SRC_URI[sha256sum] = "9543fcdcab5cf02be60e395e8145e1ec87d03a3d1f129a0dde92102283a9b536"
