require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "3f5487fe2bd5024f18f63a8d0eb4294d"
SRC_URI[sha256sum] = "788f69557ff6d28073d6ef2b3300b42b987fba1d122f7884ba0269023cab44ef"

