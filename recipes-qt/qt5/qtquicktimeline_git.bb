require qt5.inc
require qt5-git.inc

DESCRIPTION = "Qt Quick Timeline"
LICENSE = "GPL-2.0-or-later OR LicenseRef-The-Qt-Company-Commercial"
LIC_FILES_CHKSUM = " \
    file://LICENSE.GPL2;md5=b234ee4d69f5fce4486a80fdaf4a4263 \
    file://LICENSE.GPL3;md5=d32239bcb673463ab874e80d47fae504 \
    "

DEPENDS = "qtbase qtdeclarative"

SRCREV = "ea9d6c4d5a0a172b4778e8f37d694d02aab83f37"
