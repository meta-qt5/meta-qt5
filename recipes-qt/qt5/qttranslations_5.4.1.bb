require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "0bdd1b0a83b03a04a4ebeedfa3057d21"
SRC_URI[sha256sum] = "3c4d045f974bc9ee76bb85d319737cf182b8697c4ba72d2c075d3609cfaf9041"
