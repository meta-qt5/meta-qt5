require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "fe9898272b3952e3d97eacbaca484b55"
SRC_URI[sha256sum] = "632aacdac40717bf1bbc6861dc2e2d7d2825d68f40b7c1ae04636dafa20b0210"
