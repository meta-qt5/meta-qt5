require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "8dde8593750e33a79f49c5a2f03caf0c"
SRC_URI[sha256sum] = "5abb17ee60d68cf49c4f8f0b69c3f1e4d0a2f7b32cda8d6901d9c35447cc3482"
