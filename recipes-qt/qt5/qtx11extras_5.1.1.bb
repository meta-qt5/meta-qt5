require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "b5910f7f503baf56082f89bce917651b"
SRC_URI[sha256sum] = "a37f9e9436497ef96bd644b264752a415ffef57d5f5886010f079e332620c02a"
