require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "7412a5c62da71b44b9f29e29fdc6af4d"
SRC_URI[sha256sum] = "3830dd4a11727cc4a3ab32dc10e4cd016739d0b1b0c59685512853e10f1e534e"

# License files in this module still contain 2014 as year
LIC_FILES_CHKSUM = "file://LICENSE.LGPLv21;md5=cff17b12416c896e10ae2c17a64252e7 \
                    file://LICENSE.LGPLv3;md5=c1939be5579666be947371bc8120425f \
                    file://LGPL_EXCEPTION.txt;md5=0145c4d1b6f96a661c2c139dfb268fb6 \
                    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e"
