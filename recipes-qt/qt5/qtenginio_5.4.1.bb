require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "c80b967b159c513350fcfca223f435d4"
SRC_URI[sha256sum] = "aedb131c29180c7dbc41f888d6a078378a2dd3337766461734cc1b8f07e9577a"
