inherit_defer nativesdk
