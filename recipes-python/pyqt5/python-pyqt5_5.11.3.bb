require python-pyqt5.inc

DEPENDS += "sip sip-native python"

RDEPENDS_${PN} += "python-core python-sip"
